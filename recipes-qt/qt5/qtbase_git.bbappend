PACKAGECONFIG_append = " accessibility eglfs fontconfig gles2 linuxfb tslib examples"
PACKAGECONFIG_remove = "tests"

DEPENDS += "userland"
