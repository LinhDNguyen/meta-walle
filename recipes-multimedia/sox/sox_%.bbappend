PACKAGECONFIG += " pulseaudio alsa lame oggvorbis magic ao"