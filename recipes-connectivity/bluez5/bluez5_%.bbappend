EXTRA_OECONF += " --enable-mesh"
PACKAGECONFIG += " mesh"

#SYSTEMD_SERVICE_${PN} = "bluetooth.service"