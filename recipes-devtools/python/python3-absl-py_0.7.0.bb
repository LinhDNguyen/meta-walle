SUMMARY = "Abseil Python Common Libraries"
DESCRIPTION = ""
HOMEPAGE = "https://github.com/abseil/abseil-py"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/Apache-2.0;md5=89aea4e17d99a7cacdbeed46a0096b10"

SRC_URI[sha256sum] = "8718189e4bd6013bf79910b9d1cb0a76aecad8ce664f78e1144980fabdd2cd23"

inherit pypi setuptools3