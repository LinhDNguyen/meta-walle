DESCRIPTION = "A simple filesystem interface"
HOMEPAGE = "http://github.com/MatthewScholefield/fitipy"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/MIT;md5=0835ade698e0bcf8506ecda2f7b4f302"

SRC_URI[sha256sum] = "22355c35bc17a685f55093e4542d4dd04dddbfc59de52f69f42c3699fb51f979"

inherit pypi setuptools3
