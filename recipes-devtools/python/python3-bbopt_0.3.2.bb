DESCRIPTION = "The easiest hyperparameter optimization you'll ever do."
HOMEPAGE = "https://github.com/evhub/bbopt"
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/Apache-2.0;md5=89aea4e17d99a7cacdbeed46a0096b10"

SRC_URI[sha256sum] = "50f233edba300528c1b5be8ec187eaac1420198300aaddf837712539c421fef9"

inherit pypi setuptools3
