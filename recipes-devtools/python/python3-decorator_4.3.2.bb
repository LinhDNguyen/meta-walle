DESCRIPTION = "Better living through Python with decorators"
HOMEPAGE = "http://pypi.python.org/pypi/decorator"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/BSD;md5=3775480a712fc46a69647678acb234cb"

SRC_URI[sha256sum] = "33cd704aea07b4c28b3eb2c97d288a06918275dac0ecebdaf1bc8a48d98adb9e"

inherit pypi setuptools3
