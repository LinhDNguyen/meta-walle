SUMMARY = "Read/rewrite/write Python ASTs"
DESCRIPTION = ""
HOMEPAGE = "https://github.com/berkerpeksag/astor"
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://${COMMON_LICENSE_DIR}/BSD;md5=3775480a712fc46a69647678acb234cb"

SRC_URI[sha256sum] = "95c30d87a6c2cf89aa628b87398466840f0ad8652f88eb173125a6df8533fb8d"

inherit pypi setuptools3